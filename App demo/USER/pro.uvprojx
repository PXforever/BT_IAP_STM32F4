# Keil uVision project pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro
  AfterMake: D:\keil\ARM\ARMCC\bin\fromelf.exe --bin -o ..\OBJ\pro.bin ..\OBJ\pro.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\system\delay;..\system\sys;..\system\usart;..\system\sys;..\Hardware\i2c
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: mian.c startup_stm32f40_41xxx.s
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group Hardware
    ../Hardware/i2c/: i2c.c
